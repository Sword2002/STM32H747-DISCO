# Keil uVision project FreeRTOS.uvprojx, settings and files
target STM32H747XI_CM4 (6190000::V6.19::ARMCLANG)
  device: STM32H747XIHx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x10000000,0x00048000) IROM(0x08100000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FreeRTOS +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CORE_CM4,USE_HAL_DRIVER,STM32H747xx
  c include: ../Core/CM4/Inc;../Core/Common/Inc;../Drivers/BSP;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../RTOS/FreeRTOS/include;../RTOS/FreeRTOS/portable/GCC/ARM_CM4F
  asm include: ../Core/CM4/Inc
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  memory RVCT10: RAM 0x18000000 size 0x10000
  scatter file: .\stm32h747xx_flash_CM4.sct
  group Core/CM4
    ../Core/CM4/Src/: gpio.c main.c rtc.c stm32h7xx_hal_msp.c stm32h7xx_it.c usart.c
  group Core/CM7
    ../Core/CM7/Src/: gpio.c main.c quadspi.c stm32h7xx_hal_msp.c stm32h7xx_it.c task10ms.c tim.c usart.c
  group Core/Common
    ../Core/Common/Src/: button.c debug_printf.c sharemen.c system_stm32h7xx_dualcore_boot_cm4_cm7.c
  group Drivers/BSP
    ../Drivers/BSP/: stm32h747i_discovery.c stm32h747i_discovery_mt25ql_qspi.c stm32h747i_discovery_qspi.c
  group Drivers/Components
    ../Drivers/Components/mt25ql512abb/: mt25ql512abb.c
    ../Drivers/Components/mt25tl01g/: mt25tl01g.c
  group Drivers/STM3H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_fmc.c
  group MDK
    ./: startup_stm32h747xx_CM4.s startup_stm32h747xx_CM7.s
  group FS
    ../FS/: fatfsport.c littlefsport.c
  group FS/fatfs
    ../FS/fatfs/: diskio.c ff.c ffsystem.c ffunicode.c
  group FS/littlefs
    ../FS/littlefs/: lfs.c lfs_util.c
  group RTOS
    ../RTOS/: rtos_cm4.c rtos_cm7.c
  group RTOS/FreeRTOS
    ../RTOS/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group RTOS/FreeRTOS/portable
    ../RTOS/FreeRTOS/portable/MemMang/: heap_4.c
    ../RTOS/FreeRTOS/portable/Common/: mpu_wrappers.c
  group RTOS/FreeRTOS/portable_cm4
    ../RTOS/FreeRTOS/portable/GCC/ARM_CM4F/: port.c
  group RTOS/FreeRTOS/portable_cm7
    ../RTOS/FreeRTOS/portable/GCC/ARM_CM7/r0p1/: port.c
  group Shell
    ../SHELL/src/: shell.c shell_cmd_list.c shell_ext.c
  group Shell/port
    ../SHELL/port/: shell_port.c
target STM32H747XI_CM7 (6190000::V6.19::ARMCLANG)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) XRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: FreeRTOS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CORE_CM7,USE_HAL_DRIVER,STM32H747xx
  c include: ../Core/CM7/Inc;../Core/Common/Inc;../Drivers/BSP;../Drivers/Components;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../RTOS/FreeRTOS/include;../RTOS/FreeRTOS/portable/GCC/ARM_CM7/r0p1;../SHELL/src;../SHELL/port;../FS;../FS/littlefs;../FS/fatfs
  asm include: ../Core/CM7/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
