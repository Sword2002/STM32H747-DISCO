# IAR project FreeRTOS.ewp, settings and files
configuration FreeRTOS_CM4 (ARM, debug)
  General.OGChipSelectEditMenu: STM32H747XI_M4 ST STM32H747XI_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_CM4; USE_HAL_DRIVER; STM32H747xx
  ICCARM.CCIncludePath2: ../Core/CM4/Inc; ../Core/Common/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include; ../Drivers/BSP; ../RTOS/FreeRTOS/include; ../RTOS/FreeRTOS/portable/IAR/ARM_CM4F
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../Core/CM4/Inc
  OBJCOPY.OOCOutputFile: FreeRTOS_CM4.hex
  ILINK.IlinkOutputFile: FreeRTOS_CM4.out
  ILINK.IlinkIcfFile: stm32h747xx_flash_CM4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FreeRTOS_CM7 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32H747XI_M7 ST STM32H747XI_M7
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: CORE_CM7; USE_HAL_DRIVER; STM32H747xx
  ICCARM.CCIncludePath2: ../Core/CM7/Inc; ../Core/Common/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include; ../Drivers/BSP; ../RTOS/FreeRTOS/include; ../RTOS/FreeRTOS/portable/IAR/ARM_CM7/r0p1; ../SHELL/src; ../SHELL/port
  AARM.AUserIncludes: ../Core/CM7/Inc
  OBJCOPY.OOCOutputFile: FreeRTOS_CM7.hex
  ILINK.IlinkOutputFile: FreeRTOS_CM7.out
  ILINK.IlinkIcfFile: stm32h747xx_flash_CM7.icf
  group Core/CM4
    ../Core/CM4/Src/: eth.c gpio.c hdmi_cec.c main.c rtc.c stm32h7xx_hal_msp.c stm32h7xx_it.c usart.c
  group Core/CM7
    ../Core/CM7/Inc/: FreeRTOSConfig.h
    ../Core/CM7/Src/: gpio.c main.c stm32h7xx_hal_msp.c stm32h7xx_it.c task10ms.c tim.c usart.c
  group Core/Common
    ../Core/Common/Src/: button.c debug_printf.c system_stm32h7xx_dualcore_boot_cm4_cm7.c
  group Drivers/BSP
    ../Drivers/BSP/: stm32h747i_discovery.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cec.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_usb.c
  group EWARM
    ./: startup_stm32h747xx_CM4.s startup_stm32h747xx_CM7.s
  group RTOS
    ../RTOS/: rtos_cm4.c rtos_cm7.c
  group RTOS/FreeRTOS
    ../RTOS/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group RTOS/FreeRTOS/portable
    ../RTOS/FreeRTOS/portable/MemMang/: heap_4.c
    ../RTOS/FreeRTOS/portable/Common/: mpu_wrappers.c
  group RTOS/FreeRTOS/portable_cm4
    ../RTOS/FreeRTOS/portable/IAR/ARM_CM4F/: port.c portasm.s
  group RTOS/FreeRTOS/portable_cm7
    ../RTOS/FreeRTOS/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
  group Shell
    ../SHELL/src/: shell.c shell_cmd_list.c shell_ext.c
  group Shell/port
    ../SHELL/port/: shell_port.c
